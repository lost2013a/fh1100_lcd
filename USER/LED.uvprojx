# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM;..\USER;..\FWLIB\inc;..\HARDWARE;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\FWLIB\CMSIS\Include;..\APP
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c hadware.c gpstime.c
  group HARDWARE
    ../HARDWARE/: bsp_key.c can.c flash_hand.c fmc.c iwdg.c led.c rtc.c spi.c tftlcd.c timer.c w25qxx.c
  group FWLIB
    ../CORE/: startup_stm32f427_437xx.s
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_fmc.c stm32f4xx_rtc.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_flash.c
  group SYSTEM
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ../SYSTEM/: delay.c malloc.c sys.c usart.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: os_app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUI_X_Touch_Analog.c GUIConf.h
    ../EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_LIB
    ../FWLIB/CMSIS/Include/: arm_math.h
    ../FWLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../EMWIN/STemWin/Lib/: STemWin526_CM4_OS_Keil.lib
    ../EMWIN/STemWin/HanZi/: GUI_Font12.c GUI_Font16.c GUI_Font24.c GUI_Font32.c GUI_UC_EncodeNone.c GUICharPEx.c
  group GUI/MENU
    ../APP/: setmenu.c mainmenu.c devmenu.c
  group GUI/APP
    ../APP/FUC/: applist.c setapp.c
    ../APP/: items.c top.c open.c
  group GUI/APP_FUC
    ../APP/: userpass.c login.c devsn.c devlog.c
    ../APP/FUC/: app0_sysmode.c app1_usart.c app2_netport.c app3_delay.c app4_monitor.c app5_priority.c app6_ptp.c app7_am.c app8_3d.c app9_setclock.c app10_timezone.c app12_console.c app15_others.c
  group GUI/APP_STA
    ../APP/DEVSTA/: app20_Power.c app21_Fq.c app22_Alarm.c app23_BD.c app24_GPS.c app25_IRIGB1.c app26_IRIGB2.c app27_PTP1.c app28_PTP2.c app29_slot.c
  group GUI/ICON
    ../APP/ICON/: pic3.c pic2.c pic1.c MAIN_1.c MAIN_2.c MAIN_3.c MAIN_4.c MAIN_5.c set1.c set2.c set3.c set4.c left.c b1.c b2.c login1.c set5.c set6.c set7.c set8.c pic4.c sta1.c sta2.c sta3.c sta4.c sta5.c sta6.c sta7.c right.c fuhe1.c sta8.c ptp2.c pic5.c pic6.c set9.c set10.c set11.c set12.c
  group 修改记录
    ../: 修改记录.txt
